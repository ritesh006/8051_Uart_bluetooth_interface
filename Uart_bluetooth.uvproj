# Keil uVision project Uart_bluetooth.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Uart_bluetooth +hex
  c flags: Optimize=8 SizeSpeed=1
  group Application
    ./: main_bluetooth.c
  group Driver
    ./: delay.c header.h lcd.c UART_driver.c
